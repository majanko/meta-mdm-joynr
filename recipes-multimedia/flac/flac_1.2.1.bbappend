BBB_INC="/home/majanko/planck/build/tmp-eglibc/sysroots/beaglebone/usr/include/"

EXTRA_OECONF +="--includedir=${BBB_INC}"
