BBB_LIB="/home/majanko/planck/build/tmp-eglibc/sysroots/beaglebone/lib/"
EXTRA_OECONF +="--libdir=${BBB_LIB}"
