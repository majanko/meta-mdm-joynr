DESCRIPTION = "REC testing recipe. Does nothing, yust says something..."
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${WORKSPACE}/meta-mdm-joynr/files/LICENCE;md5=cf4a21270f331e068c4ae90d6711e62e"
PR = "r0"

DEPENDS = "ncurses-native"
